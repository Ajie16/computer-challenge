# Keil uVision project ISO-STM32.uvprojx, settings and files
target 单任务切换 LED (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISO-STM32
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\HARDWARE\KEY;..\..\HARDWARE\LCD;..\..\HARDWARE\LED;..\..\HARDWARE\MALLOC;..\..\HARDWARE\MP3;..\..\HARDWARE\SDIO;..\..\HARDWARE\SPI;..\..\HARDWARE\TEXT;..\..\HARDWARE\VS10XX;..\..\HARDWARE\W25QXX;..\..\HARDWARE\FATFS\doc;..\..\HARDWARE\FATFS\exfuns;..\..\HARDWARE\FATFS\src;..\..\HARDWARE\FATFS\src\option;..\..\System\delay;..\..\System\sys;..\..\System\usart;..\..\HARDWARE\DS18B20;..\..\HARDWARE\ADC;..\..\HARDWARE\EXTI;..\..\HARDWARE\DCMOTOR;..\..\HARDWARE\TIMER;..\..\HARDWARE\MOTOR;..\..\HARDWARE\24CXX;..\..\HARDWARE\IIC;..\..\HARDWARE\ld3320;..\..\HARDWARE\recorde;..\..\HARDWARE\esp32;..\..\HARDWARE\esp32\HMAC\inc;..\..\HARDWARE\esp32\HMAC\scr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group APP
    ../../User/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../User/BSP/: bsp.c bsp.h
  group uC/CPU
    ../../User/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group HARDWARE
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/LCD/: lcd.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/MALLOC/: malloc.c
    ../../HARDWARE/MP3/: mp3player.c
    ../../HARDWARE/SDIO/: sdio_sdcard.c
    ../../HARDWARE/SPI/: spi.c
    ../../HARDWARE/TEXT/: text.c
    ../../HARDWARE/VS10XX/: vs10xx.c
    ../../HARDWARE/W25QXX/: w25qxx.c
    ../../HARDWARE/DS18B20/: ds18b20.c
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/EXTI/: exti.c
    ../../HARDWARE/MOTOR/: motor.c
    ../../HARDWARE/24CXX/: 24cxx.c
    ../../HARDWARE/IIC/: myiic.c
    ../../HARDWARE/ld3320/: ld3320.c ld3320_test.c
    ../../HARDWARE/recorde/: recorder.c
  group SYSTEM
    ../../System/delay/: delay.c
    ../../System/sys/: sys.c
    ../../System/usart/: usart.c
  group FAFT
    ../../HARDWARE/FATFS/src/: diskio.c ff.c
    ../../HARDWARE/FATFS/exfuns/: exfuns.c fattester.c
    ../../HARDWARE/FATFS/src/option/: cc936.c
  group ESP32
    ../../HARDWARE/esp32/: mqtt.c timer1.c timer3.c timer4.c usart2.c wifi.c
    ../../HARDWARE/esp32/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
